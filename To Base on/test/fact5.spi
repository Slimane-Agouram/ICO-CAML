    .data
nl:
    .asciiz "\n"
    .align 2
allocs:
    .asciiz "Alloc: "
    .align 2
Glob:
    .space 4
    .align 2
Mem:
    .space 16000
    .text
    .globl __start
    .align 2

print_int:
    li  $v0, 1
    syscall
    j   $ra
println_int:
    li  $v0, 1
    syscall
    la  $a0, nl
    li  $v0, 4
    syscall
    j   $ra
read_int:
    li  $v0, 5
    syscall
    j   $ra
alloc:
    sw  $a0, ($fp)
    sll $a0, $a0, 2
    addu $v0, $fp, 4
    addu $fp, $v0, $a0
    j   $ra

__start:
    la    $fp, Mem
    la    $gp, Glob
    jal  main
    li    $v0, 10
    syscall

#FUNSTART fact
    fact_f=0
fact:
    li   $v0, 1
    b    L13
L12:
    mul  $v0, $v0, $a0
    sub  $a0, $a0, 1
L13:
    bgt  $a0, $zero, L12
L14:
fact_end:
    j    $ra

#FUNSTART main
    main_f=4
main:
    subu $sp, $sp, main_f
    sw   $ra, 0($sp) # store $121
    jal  read_int
    sw   $v0, 0($gp)
    lw   $a0, 0($gp)
    jal  fact
    move $a0, $v0
    jal  println_int
main_end:
    lw   $ra, 0($sp) # load  $121
    addu $sp, $sp, main_f
    j    $ra
