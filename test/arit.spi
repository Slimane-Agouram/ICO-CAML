    .data
nl:
    .asciiz "\n"
    .align 2
allocs:
    .asciiz "Alloc: "
    .align 2
Glob:
    .space 4
    .align 2
Mem:
    .space 16000
    .text
    .globl __start
    .align 2

print_int:
    li  $v0, 1
    syscall
    j   $ra
println_int:
    li  $v0, 1
    syscall
    la  $a0, nl
    li  $v0, 4
    syscall
    j   $ra
read_int:
    li  $v0, 5
    syscall
    j   $ra
alloc:
    sw  $a0, ($fp)
    sll $a0, $a0, 2
    addu $v0, $fp, 4
    addu $fp, $v0, $a0
    j   $ra

__start:
    la    $fp, Mem
    la    $gp, Glob
    jal  main
    li    $v0, 10
    syscall

#FUNSTART coucou
    coucou_f=0
coucou:
    move $a2, $ra
    move $t0, $a0
    mul  $v0, $t0, $t0
    add  $a1, $t0, $t0
    add  $v0, $v0, $a1
    mul  $a1, $t0, $t0
    add  $v0, $v0, $a1
    add  $a1, $t0, $t0
    add  $v0, $v0, $a1
    mul  $a1, $t0, $t0
    add  $a3, $t0, $t0
    add  $a1, $a1, $a3
    mul  $a3, $t0, $t0
    add  $a1, $a1, $a3
    add  $a3, $t0, $t0
    add  $a1, $a1, $a3
    add  $t1, $v0, $a1
    mul  $v0, $t0, $t0
    add  $a1, $t0, $t0
    add  $v0, $v0, $a1
    mul  $a1, $t0, $t0
    add  $v0, $v0, $a1
    add  $a1, $t0, $t0
    add  $v0, $v0, $a1
    mul  $a1, $t0, $t0
    add  $a3, $t0, $t0
    add  $a1, $a1, $a3
    mul  $a3, $t0, $t0
    add  $a1, $a1, $a3
    add  $a3, $t0, $t0
    add  $a1, $a1, $a3
    add  $v0, $v0, $a1
    add  $t1, $t1, $v0
    mul  $v0, $t0, $t0
    add  $a1, $t0, $t0
    add  $v0, $v0, $a1
    mul  $a1, $t0, $t0
    add  $v0, $v0, $a1
    add  $a1, $t0, $t0
    add  $v0, $v0, $a1
    mul  $a1, $t0, $t0
    add  $a3, $t0, $t0
    add  $a1, $a1, $a3
    mul  $a3, $t0, $t0
    add  $a1, $a1, $a3
    add  $a3, $t0, $t0
    add  $a1, $a1, $a3
    add  $t2, $v0, $a1
    mul  $v0, $t0, $t0
    add  $a1, $t0, $t0
    add  $v0, $v0, $a1
    mul  $a1, $t0, $t0
    add  $v0, $v0, $a1
    add  $a1, $t0, $t0
    add  $v0, $v0, $a1
    mul  $a1, $t0, $t0
    add  $a3, $t0, $t0
    add  $a1, $a1, $a3
    mul  $a3, $t0, $t0
    add  $a1, $a1, $a3
    add  $a3, $t0, $t0
    add  $a1, $a1, $a3
    add  $v0, $v0, $a1
    add  $v0, $t2, $v0
    add  $a1, $t1, $v0
    move $a0, $a1
    jal  println_int
    add  $a3, $a1, $t0
    move $a0, $a3
    jal  println_int
    add  $v0, $a1, $a3
    add  $t1, $v0, $t0
    move $a0, $t1
    jal  println_int
    add  $v0, $t1, $a1
    add  $v0, $v0, $a3
    add  $a0, $v0, $t0
    jal  println_int
    sub  $v0, $t0, $t0
    sub  $v0, $v0, $t0
    sub  $v0, $v0, $t0
    sub  $a0, $v0, $t0
    jal  println_int
    sub  $v0, $t0, $t0
    sub  $v0, $t0, $v0
    sub  $v0, $t0, $v0
    sub  $a0, $t0, $v0
    jal  println_int
    sub  $v0, $zero, 10
    mul  $a0, $t0, $v0
    jal  println_int
    sra  $a0, $t0, 2
    jal  println_int
    sra  $v0, $t0, 2
    sll  $v0, $v0, 2
    sub  $a0, $t0, $v0
    jal  println_int
coucou_end:
    move $ra, $a2
    j    $ra

#FUNSTART main
    main_f=4
main:
    subu $sp, $sp, main_f
    sw   $ra, 0($sp) # store $197
    jal  read_int
    sw   $v0, 0($gp)
    b    L13
L12:
    lw   $a0, 0($gp)
    jal  coucou
    jal  read_int
    sw   $v0, 0($gp)
L13:
    lw   $v0, 0($gp)
    bne  $v0, $zero, L12
main_end:
    lw   $ra, 0($sp) # load  $197
    addu $sp, $sp, main_f
    j    $ra
