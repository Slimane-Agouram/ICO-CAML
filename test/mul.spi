    .data
nl:
    .asciiz "\n"
    .align 2
allocs:
    .asciiz "Alloc: "
    .align 2
Glob:
    .space 8
    .align 2
Mem:
    .space 16000
    .text
    .globl __start
    .align 2

print_int:
    li  $v0, 1
    syscall
    j   $ra
println_int:
    li  $v0, 1
    syscall
    la  $a0, nl
    li  $v0, 4
    syscall
    j   $ra
read_int:
    li  $v0, 5
    syscall
    j   $ra
alloc:
    sw  $a0, ($fp)
    sll $a0, $a0, 2
    addu $v0, $fp, 4
    addu $fp, $v0, $a0
    j   $ra

__start:
    la    $fp, Mem
    la    $gp, Glob
    jal  main
    li    $v0, 10
    syscall

#FUNSTART lire
    lire_f=0
lire:
    move $a2, $ra
    lw   $v0, 0($gp)
    lw   $a0, 0($gp)
    mul  $a0, $v0, $a0
    jal  alloc
    move $a0, $v0
    move $a1, $zero
    b    L19
L18:
    move $a3, $zero
    b    L22
L21:
    jal  read_int
    lw   $t0, 0($gp)
    mul  $t0, $t0, $a1
    add  $t0, $t0, $a3
    sll  $t0, $t0, 2
    addu $t0, $a0, $t0
    sw   $v0, 0($t0)
    add  $a3, $a3, 1
L22:
    lw   $t0, 0($gp)
    blt  $a3, $t0, L21
L23:
    add  $a1, $a1, 1
L19:
    lw   $a3, 0($gp)
    blt  $a1, $a3, L18
L20:
    move $v0, $a0
lire_end:
    move $ra, $a2
    j    $ra

#FUNSTART affiche
    affiche_f=0
affiche:
    move $t0, $ra
    move $a1, $a0
    move $a2, $zero
    b    L25
L24:
    move $a3, $zero
    b    L28
L27:
    lw   $v0, 0($gp)
    mul  $v0, $v0, $a2
    add  $v0, $v0, $a3
    sll  $v0, $v0, 2
    addu $v0, $a1, $v0
    lw   $a0, 0($v0)
    jal  println_int
    add  $a3, $a3, 1
L28:
    lw   $v0, 0($gp)
    blt  $a3, $v0, L27
L29:
    add  $a2, $a2, 1
L25:
    lw   $v0, 0($gp)
    blt  $a2, $v0, L24
affiche_end:
    move $ra, $t0
    j    $ra

#FUNSTART matmult
    matmult_f=0
matmult:
    move $a3, $ra
    move $t1, $a0
    lw   $v0, 0($gp)
    lw   $a2, 0($gp)
    mul  $a0, $v0, $a2
    jal  alloc
    move $t2, $zero
    b    L31
L30:
    move $t3, $zero
    b    L34
L33:
    move $t4, $zero
    move $t5, $zero
    b    L37
L36:
    lw   $a2, 0($gp)
    mul  $a2, $a2, $t2
    add  $a2, $a2, $t4
    sll  $a2, $a2, 2
    addu $a2, $t1, $a2
    lw   $a2, 0($a2)
    lw   $t0, 0($gp)
    mul  $t0, $t0, $t4
    add  $t0, $t0, $t3
    sll  $t0, $t0, 2
    addu $t0, $a1, $t0
    lw   $t0, 0($t0)
    mul  $a2, $a2, $t0
    add  $t5, $t5, $a2
    add  $t4, $t4, 1
L37:
    lw   $a2, 0($gp)
    blt  $t4, $a2, L36
L38:
    lw   $a2, 0($gp)
    mul  $a2, $a2, $t2
    add  $a2, $a2, $t3
    sll  $a2, $a2, 2
    addu $a2, $v0, $a2
    sw   $t5, 0($a2)
    add  $t3, $t3, 1
L34:
    lw   $a2, 0($gp)
    blt  $t3, $a2, L33
L35:
    add  $t2, $t2, 1
L31:
    lw   $a2, 0($gp)
    blt  $t2, $a2, L30
L32:
matmult_end:
    move $ra, $a3
    j    $ra

#FUNSTART pow
    pow_f=12
pow:
    subu $sp, $sp, pow_f
    sw   $ra, 0($sp) # store $202
    sw   $s0, 4($sp) # store $203
    sw   $s1, 8($sp) # store $204
    move $s1, $a0
    move $s0, $a1
    li   $a2, 1
    beq  $s1, $a2, L39
L40:
    sra  $a0, $s1, 1
    move $a1, $s0
    jal  pow
    move $a0, $v0
    move $a1, $v0
    jal  matmult
    sra  $a2, $s1, 1
    sll  $a2, $a2, 1
    beq  $a2, $s1, L42
L43:
    move $a0, $s0
    move $a1, $v0
    jal  matmult
    b    pow_end
L42:
    b    pow_end
L39:
    move $v0, $s0
pow_end:
    lw   $ra, 0($sp) # load  $202
    lw   $s0, 4($sp) # load  $203
    lw   $s1, 8($sp) # load  $204
    addu $sp, $sp, pow_f
    j    $ra

#FUNSTART main
    main_f=4
main:
    subu $sp, $sp, main_f
    sw   $ra, 0($sp) # store $214
    jal  read_int
    sw   $v0, 0($gp)
    jal  lire
    sw   $v0, 4($gp)
    lw   $a0, 0($gp)
    lw   $a1, 4($gp)
    jal  pow
    move $a0, $v0
    jal  affiche
main_end:
    lw   $ra, 0($sp) # load  $214
    addu $sp, $sp, main_f
    j    $ra
